# Keil uVision project stm32f0x.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.0.3
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F072xB USE_FULL_LL_DRIVER
  c include: ..\..\..\mcu\stm32f0x\Libraries\CMSIS\Include;..\..\..\mcu\stm32f0x\Libraries\STM32F0xx_HAL_Driver\Inc;..\..\..\mcu\stm32f0x\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\mcu\stm32f0x\ebox;..\..\..\mcu\stm32f0x\ebox\core;..\..\..\mcu\stm32f0x\ebox\Peripherals;..\..\..\common\util;..\..\..\common\edriver;..\..\..\common\network;..\..\..\common\fat;..\..\..\common\edriver\WiFi;..\..\..\user;..\..\..\common\util\printf
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group start_code
    ../../../mcu/stm32f0x/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030xc.s startup_stm32f030x6.s startup_stm32f030x8.s startup_stm32f031x6.s startup_stm32f038xx.s startup_stm32f042x6.s startup_stm32f048xx.s startup_stm32f051x8.s startup_stm32f058xx.s startup_stm32f070x6.s startup_stm32f070xb.s startup_stm32f071xb.s startup_stm32f072xb.s startup_stm32f078xx.s startup_stm32f091xc.s startup_stm32f098xx.s
  group CMSIS
    ../../../mcu/stm32f0x/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group libraries_LL
    ../../../mcu/stm32f0x/Libraries/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_utils.c stm32f0xx_ll_rcc.c stm32f0xx_ll_i2c.c
  group ebox
    ../../../mcu/stm32f0x/ebox/core/: common.cpp core.cpp ebox_it.cpp
    ../../../mcu/stm32f0x/ebox/Peripherals/: analog.cpp exti.cpp gpio.cpp i2c.cpp iflash.cpp in_capture.cpp pwm.cpp rtc.cpp softi2c.cpp softspi.cpp SPI.cpp timer.cpp uart.cpp wdg.cpp
    ../../../mcu/stm32f0x/ebox/: object.cpp
  group util
    ../../../common/util/: dtostrf.c heap.c itoa.c calendar.cpp color_convert.cpp ringbuf.cpp util.cpp WString.cpp
    ../../../common/util/printf/: printf.cpp
  group edriver
    ../../../common/edriver/: 74HC595.cpp at24c02.cpp at45db.cpp Button.cpp colorled.cpp dht11.cpp DS3231.cpp encoder.cpp fm25v.cpp GP2Y1051.cpp ir_decoder.cpp ir_encoder.cpp key_dm.cpp L3G4200D.cpp lcd_1.8.cpp LCD1602.cpp LED.cpp led_segment.cpp lsm303dhlc.cpp LTC1446.cpp Max7456.cpp mmc_sd.cpp MPU6050.CPP Nokia5110.cpp NRF24L01.cpp OLED.cpp OLED_ssd1306.cpp parallel_gpio.cpp TM1638.cpp ultrasonic_wave.cpp w25x16.cpp w5500.cpp
  group network
    ../../../common/network/: socket.cpp dhcp.cpp dns.cpp tcp.cpp udp.cpp
  group fat
    ../../../common/fat/: wrapperdiskio.cpp diskio.c ff.c
  group wifi
    ../../../common/edriver/WiFi/: ESP8266.cpp esp8266_tcp.cpp esp8266_udp.cpp
  group user
    ../../../user/: main.cpp bsp.cpp
